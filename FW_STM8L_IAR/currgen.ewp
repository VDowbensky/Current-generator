# IAR project currgen.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; STM8L151K6; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: D:\Projects\Lab equipment\Current-generator\FW_STM8L_IAR\src; D:\Projects\Lab equipment\Current-generator\FW_STM8L_IAR\inc; D:\Projects\Lab equipment\Current-generator\FW_STM8L_IAR\STM8L15x_StdPeriph_Driver\src; D:\Projects\Lab equipment\Current-generator\FW_STM8L_IAR\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: currgen.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: dac.h eep.h eeprom.h gpio_interface.h macro.h main.h spi_interface.h stm8l15x_conf.h stm8l15x_it.h testmode.h uart_commands.h uart_interface.h user_settings.h
  group lib
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group src
    src/: dac.c eep.c eeprom.c gpio_interface.c main.c spi_interface.c stm8l15x_it.c testmode.c uart_commands.c uart_interface.c
