# Keil uVision project currgen100.uvprojx, settings and files
target STM32F100C4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: currgen100 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_VL_LD, USE_STDPERIPH_DRIVER
  c include: .\include;.\source;.\startup;.\std_lib\inc;.\std_lib\src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./source/: eeprom.c gpio.c main.c spi.c testmode.c timers.c uart.c uart_commands.c
  group Startup
    ./startup/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_ld_vl.s
  group library
    ./std_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
